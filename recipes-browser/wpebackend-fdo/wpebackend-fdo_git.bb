require wpebackend-fdo.inc

PV = "0.1~git"

SRCREV = "84b79d87e4581dd95a74ee60c2f1755ed620bbe4"
SRC_URI = "git://github.com/Igalia/WPEBackend-fdo.git;protocol=https;branch=linux-dmabuf"

S = "${WORKDIR}/git"
