SRC_URI_remove = "file://CVE-2018-1000073.patch"
